# Keil uVision project Host_demo2.0.uvprojx, settings and files
target Host_demo2.0 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: SKEAZ128xxx4 NXP
  pack: Keil.Kinetis_KEAxx_DFP.1.3.0
  cpu: IRAM(0x1FFFF000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Host_demo
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source
    ./Sources/: CLK.c main.c serializer_select.c
    ./Headers/: adc.c i2c.c ics.c kbi.c nvic.c pit.c rtc.c wdog.c uart.c
    ./Sources/MAXIM_ser/: max_serializer_ctrl.c max_serializer_data.c max_serializer_if.c
    ./Sources/TI_ser/: ti_serializer_ctrl.c ti_serializer_data.c ti_serializer_if.c atmel_1189.c
    ./Sources/APP_Communicate/: APP_COMM_data.c APP_COMM_if.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
